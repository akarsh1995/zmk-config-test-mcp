## boards/shields/mcptest/Kconfig.defconfig
```kconfig
if SHIELD_MCPTEST

config ZMK_KEYBOARD_NAME
    default "mcptest"

endif # SHIELD_MCPTEST
```
